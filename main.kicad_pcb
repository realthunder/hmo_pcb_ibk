# Repository realthunder/hmo_pcb_ibk

## KiCad design main.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1uF; C_0402
D1: SFH3710; LED_0805
P1: CONN_ProMini_Up; Molex_PicoBlade_53261-0771
P2: CONN_ProMini_Down2; Molex_Panelmate-53780-0570_05x1.25mm_Angled
P3: CON_MT; Molex_PicoBlade_53398-0771
P4: CON_POLOLU_DRV8834; Pin_Header_Straight_1x05
P5: CON_ProMini_Down; Molex_Panelmate-53780-0670_06x1.25mm_Angled
P6: CONN_SRV; Molex_PicoBlade_53048-0410
P10: CON_SHD; Pin_Header_Straight_1x02_Pitch1.27mm
R1, R2: 10K; R_0402
U1: 74AHC1G04; SOT-353
U2: MIC2514; SOT-23-5
U3: DRV8838; DRV8838_DSG_8
U4: 74LVC2G126; SN74LVC2G126_DCU_8

Connections:
/BL_CI: P5.2, U4.3
/BL_CS: P1.4, U4.1, U4.7
/BL_DO: P5.3, U4.2
/LIGHT: D1.1 (K), P2.2, R1.1
/MISO: P1.6, U4.6
/MT_DIR: P3.4, P5.1, U1.2
/PWR_SEL: P2.3, U2.1 (CTL), U3.7 (NSLEEP)
/SCLK: P1.5, U4.5
/SHD_DRV: P5.4, U3.6 (PH)
/SHD_N: P10.2, U3.3 (OUT2)
/SHD_P: P10.1, U3.2 (OUT1)
/SOL_DIR: P1.3, P4.5 (DIR)
/SOL_EN: P1.2, P4.4 (STEP)
/SRV1: P5.6, P6.1
/SRV2: P5.5, P6.2
/VMOT: P3.2, P6.3, U2.4 (OUT), U2.5 (NC)
/VREG: C1.1, C3.1, P2.5, U2.3 (IN), U3.1 (VM)
/~STEP_SLP: P1.1, P4.3 (~SLP), U3.5 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, P2.1, P3.3, P4.2 ((REF)), P6.4, R1.2, U1.3 (GND), U2.2 (GND), U3.4 (GND), U4.4 (GND)
VCC: C2.1, C4.1, C5.1, D1.2 (A), P2.4, P3.1, P4.1 ((CFG)), R2.2, U1.5 (VCC), U3.8 (VCC), U4.8 (VCC)

Notes on the sheet:
Jumper wires to get the power
Make this receptacle
Make this receptacle
Use receptacle here

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
Board: 2 copper layers, 26.7 x 19.1 mm, 20 parts (13 on the bottom side), 22 nets.

Other parts of the board:
__P2: Molex_Panelmate-51146-0500

## Commit log

2016-06-08 added backlight pcb design
2016-06-08 Modified breakout PCB design
2016-06-23 Added missing project file
2016-06-23 Modified pcb design
2016-06-23 Removing backlight submodule
2016-06-23 Renamed project
2016-06-24 Fixed motor stopper pullup
2016-06-24 Added new footprints
2016-06-24 Modified drv8835 connector
2016-07-12 Fixed schematics
2016-10-26 Added missing files

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
